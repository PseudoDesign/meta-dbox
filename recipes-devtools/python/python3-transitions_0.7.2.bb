DESCRIPTION = "A state-machine library for Python"
HOMEPAGE = "https://github.com/pytransitions/transitions"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8734a2c2e13bbf9c2fd1b6cb64af8219"

PYPI_PACKAGE = "transitions"
inherit pypi setuptools3

SRC_URI[md5sum] = "5a0df4ba41e89ae8ebbcae5ecf30710c"
SRC_URI[sha256sum] = "5566c9d32e438ee9eb1f046e3ac1a0b2689f32807b47859210162084d4c84ab7"

