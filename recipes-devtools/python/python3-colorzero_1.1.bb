DESCRIPTION = "Color manipulatio library in Python"
HOMEPAGE = "https://colorzero.readthedocs.io/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=b2854a8defdf90fac461ff4aba9cc0ea"

PYPI_PACKAGE = "colorzero"
inherit pypi setuptools3

SRC_URI[md5sum] = "7581c4b7fc5f52bf41422e4bbb29731a"
SRC_URI[sha256sum] = "acba47119b5d8555680d3cda9afe6ccc5481385ccc3c00084dd973f7aa184599"
