DESCRIPTION = "Dbox Application"
SECTION = "devel/python"
LICENSE = "CLOSED"

RDEPENDS_${PN} = "\
  python3-rpi-gpio \
  python3-pyyaml \
  python3-bcrypt \
  python3-transitions \
  python3-gpiozero \
  python3-dbus \
  python3-sdnotify \
  python3-colorzero \
  python3-pycparser \
"